** sch_path: cace/templates/transient.sch
**.subckt transient
V0 VGND GND 0
V2 VDPWR GND CACE{vdpwr}
.save i(v2)
x1 net1 VDPWR vprogmon VAPWR VGND VGND VGND VGND VGND VDPWR VDPWR net2 net3 VGND net4 VGND net5 VGND
+ net6 VGND net7 VGND net8 net9 VGND net10 VGND net11 VGND net12 VGND net13 VGND net14 VGND net15 VGND
+ net16 VGND net17 net18 net19 net20 net21 net22 net23 net24 tt_um_sonos_flash_party
V1 VAPWR GND CACE{vapwr}
.save i(v1)
R1 VGND vprogmon CACE{oload} m=1
**** begin user architecture code


.control
    * Step function applied at time 100ns, save transient data
    tran 10n CACE{Tmax}
    set wr_singlescale
    wrdata CACE{simpath}/CACE{filename}_CACE{N}.data vprogmon
.endc




.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL VGND
.GLOBAL GND
.end
